# Keil uVision project ble_app_hrs_pca10040_s132.uvprojx, settings and files
target nrf52832_xxaa (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.42.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BL_SETTINGS_ACCESS_ONLY NRF_DFU_SVCI_ENABLED NRF_DFU_TRANSPORT_BLE=1 BLE_STACK_SUPPORT_REQD BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD MBEDTLS_CONFIG_FILE=<nrf_crypto_mbedtls_config.h> NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_CRYPTO_MAX_INSTANCE_COUNT=1 NRF_SD_BLE_API_VERSION=6 S132 SOFTDEVICE_PRESENT SWI_DISABLE0 __HEAP_SIZE=8192 __STACK_SIZE=8192 uECC_ENABLE_VLI_API=0 uECC_OPTIMIZATION_LEVEL=3 uECC_SQUARE_FUNC=0 uECC_SUPPORT_COMPRESSED_POINT=0 uECC_VLI_NATIVE_LITTLE_ENDIAN=1 DEBUG
  c misc: --reduce_paths
  c include: .\config;..\nRF5_SDK_15.2.0\components;..\nRF5_SDK_15.2.0\components\ble\ble_advertising;..\nRF5_SDK_15.2.0\components\ble\ble_dtm;..\nRF5_SDK_15.2.0\components\ble\ble_racp;..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_ancs_c;..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_ans_c;..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_bas;..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_bas_c;..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_cscs;..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_cts_c;..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_dfu;..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_dis;..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_gls;..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_hids;..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_hrs;..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_hrs_c;..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_hts;..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_ias;..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_ias_c;..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_lbs;..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_lbs_c;..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_lls;..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_nus;..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_nus_c;..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_rscs;..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_rscs_c;..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_tps;..\nRF5_SDK_15.2.0\components\ble\common;..\nRF5_SDK_15.2.0\components\ble\nrf_ble_gatt;..\nRF5_SDK_15.2.0\components\ble\nrf_ble_qwr;..\nRF5_SDK_15.2.0\components\ble\peer_manager;..\nRF5_SDK_15.2.0\components\boards;..\nRF5_SDK_15.2.0\components\drivers_nrf\usbd;..\nRF5_SDK_15.2.0\components\libraries\atomic;..\nRF5_SDK_15.2.0\components\libraries\atomic_fifo;..\nRF5_SDK_15.2.0\components\libraries\atomic_flags;..\nRF5_SDK_15.2.0\components\libraries\balloc;..\nRF5_SDK_15.2.0\components\libraries\bootloader\ble_dfu;..\nRF5_SDK_15.2.0\components\libraries\bsp;..\nRF5_SDK_15.2.0\components\libraries\button;..\nRF5_SDK_15.2.0\components\libraries\cli;..\nRF5_SDK_15.2.0\components\libraries\crc16;..\nRF5_SDK_15.2.0\components\libraries\crc32;..\nRF5_SDK_15.2.0\components\libraries\crypto;..\nRF5_SDK_15.2.0\components\libraries\crypto\backend\cc310;..\nRF5_SDK_15.2.0\components\libraries\crypto\backend\cc310_bl;..\nRF5_SDK_15.2.0\components\libraries\crypto\backend\cifra;..\nRF5_SDK_15.2.0\components\libraries\crypto\backend\mbedtls;..\nRF5_SDK_15.2.0\components\libraries\crypto\backend\micro_ecc;..\nRF5_SDK_15.2.0\components\libraries\crypto\backend\nrf_hw;..\nRF5_SDK_15.2.0\components\libraries\crypto\backend\nrf_sw;..\nRF5_SDK_15.2.0\components\libraries\crypto\backend\oberon;..\nRF5_SDK_15.2.0\components\libraries\csense;..\nRF5_SDK_15.2.0\components\libraries\csense_drv;..\nRF5_SDK_15.2.0\components\libraries\delay;..\nRF5_SDK_15.2.0\components\libraries\ecc;..\nRF5_SDK_15.2.0\components\libraries\experimental_section_vars;..\nRF5_SDK_15.2.0\components\libraries\experimental_task_manager;..\nRF5_SDK_15.2.0\components\libraries\fds;..\nRF5_SDK_15.2.0\components\libraries\fstorage;..\nRF5_SDK_15.2.0\components\libraries\gfx;..\nRF5_SDK_15.2.0\components\libraries\gpiote;..\nRF5_SDK_15.2.0\components\libraries\hardfault;..\nRF5_SDK_15.2.0\components\libraries\hci;..\nRF5_SDK_15.2.0\components\libraries\led_softblink;..\nRF5_SDK_15.2.0\components\libraries\log;..\nRF5_SDK_15.2.0\components\libraries\log\src;..\nRF5_SDK_15.2.0\components\libraries\low_power_pwm;..\nRF5_SDK_15.2.0\components\libraries\mem_manager;..\nRF5_SDK_15.2.0\components\libraries\memobj;..\nRF5_SDK_15.2.0\components\libraries\mpu;..\nRF5_SDK_15.2.0\components\libraries\mutex;..\nRF5_SDK_15.2.0\components\libraries\pwm;..\nRF5_SDK_15.2.0\components\libraries\pwr_mgmt;..\nRF5_SDK_15.2.0\components\libraries\queue;..\nRF5_SDK_15.2.0\components\libraries\ringbuf;..\nRF5_SDK_15.2.0\components\libraries\scheduler;..\nRF5_SDK_15.2.0\components\libraries\sdcard;..\nRF5_SDK_15.2.0\components\libraries\sensorsim;..\nRF5_SDK_15.2.0\components\libraries\slip;..\nRF5_SDK_15.2.0\components\libraries\sortlist;..\nRF5_SDK_15.2.0\components\libraries\spi_mngr;..\nRF5_SDK_15.2.0\components\libraries\stack_guard;..\nRF5_SDK_15.2.0\components\libraries\stack_info;..\nRF5_SDK_15.2.0\components\libraries\strerror;..\nRF5_SDK_15.2.0\components\libraries\svc;..\nRF5_SDK_15.2.0\components\libraries\timer;..\nRF5_SDK_15.2.0\components\libraries\twi_mngr;..\nRF5_SDK_15.2.0\components\libraries\twi_sensor;..\nRF5_SDK_15.2.0\components\libraries\usbd;..\nRF5_SDK_15.2.0\components\libraries\usbd\class\audio;..\nRF5_SDK_15.2.0\components\libraries\usbd\class\cdc;..\nRF5_SDK_15.2.0\components\libraries\usbd\class\cdc\acm;..\nRF5_SDK_15.2.0\components\libraries\usbd\class\hid;..\nRF5_SDK_15.2.0\components\libraries\usbd\class\hid\generic;..\nRF5_SDK_15.2.0\components\libraries\usbd\class\hid\kbd;..\nRF5_SDK_15.2.0\components\libraries\usbd\class\hid\mouse;..\nRF5_SDK_15.2.0\components\libraries\usbd\class\msc;..\nRF5_SDK_15.2.0\components\libraries\util;..\nRF5_SDK_15.2.0\components\nfc\ndef\conn_hand_parser;..\nRF5_SDK_15.2.0\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\nRF5_SDK_15.2.0\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\nRF5_SDK_15.2.0\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\nRF5_SDK_15.2.0\components\nfc\ndef\connection_handover\ac_rec;..\nRF5_SDK_15.2.0\components\nfc\ndef\connection_handover\ble_oob_advdata;..\nRF5_SDK_15.2.0\components\nfc\ndef\connection_handover\ble_pair_lib;..\nRF5_SDK_15.2.0\components\nfc\ndef\connection_handover\ble_pair_msg;..\nRF5_SDK_15.2.0\components\nfc\ndef\connection_handover\common;..\nRF5_SDK_15.2.0\components\nfc\ndef\connection_handover\ep_oob_rec;..\nRF5_SDK_15.2.0\components\nfc\ndef\connection_handover\hs_rec;..\nRF5_SDK_15.2.0\components\nfc\ndef\connection_handover\le_oob_rec;..\nRF5_SDK_15.2.0\components\nfc\ndef\generic\message;..\nRF5_SDK_15.2.0\components\nfc\ndef\generic\record;..\nRF5_SDK_15.2.0\components\nfc\ndef\launchapp;..\nRF5_SDK_15.2.0\components\nfc\ndef\parser\message;..\nRF5_SDK_15.2.0\components\nfc\ndef\parser\record;..\nRF5_SDK_15.2.0\components\nfc\ndef\text;..\nRF5_SDK_15.2.0\components\nfc\ndef\uri;..\nRF5_SDK_15.2.0\components\nfc\t2t_lib;..\nRF5_SDK_15.2.0\components\nfc\t2t_lib\hal_t2t;..\nRF5_SDK_15.2.0\components\nfc\t2t_parser;..\nRF5_SDK_15.2.0\components\nfc\t4t_lib;..\nRF5_SDK_15.2.0\components\nfc\t4t_lib\hal_t4t;..\nRF5_SDK_15.2.0\components\nfc\t4t_parser\apdu;..\nRF5_SDK_15.2.0\components\nfc\t4t_parser\cc_file;..\nRF5_SDK_15.2.0\components\nfc\t4t_parser\hl_detection_procedure;..\nRF5_SDK_15.2.0\components\nfc\t4t_parser\tlv;..\nRF5_SDK_15.2.0\components\softdevice\common;..\nRF5_SDK_15.2.0\components\softdevice\s132\headers;..\nRF5_SDK_15.2.0\components\softdevice\s132\headers\nrf52;..\nRF5_SDK_15.2.0\external\fprintf;..\nRF5_SDK_15.2.0\external\mbedtls\include;..\nRF5_SDK_15.2.0\external\micro-ecc\micro-ecc;..\nRF5_SDK_15.2.0\external\nrf_cc310\include;..\nRF5_SDK_15.2.0\external\nrf_oberon;..\nRF5_SDK_15.2.0\external\nrf_oberon\include;..\nRF5_SDK_15.2.0\external\nrf_tls\mbedtls\nrf_crypto\config;..\nRF5_SDK_15.2.0\external\segger_rtt;..\nRF5_SDK_15.2.0\external\utf_converter;..\nRF5_SDK_15.2.0\modules\nrfx;..\nRF5_SDK_15.2.0\modules\nrfx\drivers\include;..\nRF5_SDK_15.2.0\modules\nrfx\hal;..\nRF5_SDK_15.2.0\modules\nrfx\mdk;..\config;..\nRF5_SDK_15.2.0\integration\nrfx;..\nRF5_SDK_15.2.0\components\libraries\uart;.\afe4409;..\nRF5_SDK_15.2.0\integration\nrfx\legacy;.\twi;..\ISL_Wristband_DFU_ver1.1;..\nRF5_SDK_15.2.0\components\libraries\fifo;..\nRF5_SDK_15.2.0\components\ble\ble_services\ble_dfu;..\nRF5_SDK_15.2.0\components\libraries\bootloader\dfu;..\nRF5_SDK_15.2.0\components\libraries\bootloader;..\nRF5_SDK_15.2.0\components\libraries\svc;..\nRF5_SDK_15.2.0\components\ble\ble_link_ctx_manager;..\all_data_all_display
  asm define: BLE_STACK_SUPPORT_REQD BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_CRYPTO_MAX_INSTANCE_COUNT=1 NRF_SD_BLE_API_VERSION=6 S132 SOFTDEVICE_PRESENT SWI_DISABLE0 __HEAP_SIZE=8192 __STACK_SIZE=8192 uECC_ENABLE_VLI_API=0 uECC_OPTIMIZATION_LEVEL=3 uECC_SQUARE_FUNC=0 uECC_SUPPORT_COMPRESSED_POINT=0 uECC_VLI_NATIVE_LITTLE_ENDIAN=1
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DNRF_CRYPTO_MAX_INSTANCE_COUNT=1,-DNRF_SD_BLE_API_VERSION=6,-DS132,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192,-DuECC_ENABLE_VLI_API=0,-DuECC_OPTIMIZATION_LEVEL=3,-DuECC_SQUARE_FUNC=0,-DuECC_SUPPORT_COMPRESSED_POINT=0,-DuECC_VLI_NATIVE_LITTLE_ENDIAN=1
  asm include: ..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\components\ble\ble_racp;..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\..\..\..\components\ble\ble_services\ble_cscs;..\..\..\..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\components\ble\ble_services\ble_gls;..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\components\ble\ble_services\ble_hts;..\..\..\..\..\..\components\ble\ble_services\ble_ias;..\..\..\..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\..\..\..\components\ble\ble_services\ble_lbs;..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\..\components\ble\ble_services\ble_lls;..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\..\..\..\components\ble\ble_services\ble_rscs;..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\..\components\ble\ble_services\ble_tps;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\nrf_ble_gatt;..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\usbd;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\components\libraries\atomic_flags;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bootloader\ble_dfu;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\cli;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\components\libraries\crypto;..\..\..\..\..\..\components\libraries\crypto\backend\cc310;..\..\..\..\..\..\components\libraries\crypto\backend\cc310_bl;..\..\..\..\..\..\components\libraries\crypto\backend\cifra;..\..\..\..\..\..\components\libraries\crypto\backend\mbedtls;..\..\..\..\..\..\components\libraries\crypto\backend\micro_ecc;..\..\..\..\..\..\components\libraries\crypto\backend\nrf_hw;..\..\..\..\..\..\components\libraries\crypto\backend\nrf_sw;..\..\..\..\..\..\components\libraries\crypto\backend\oberon;..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\components\libraries\ecc;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\experimental_task_manager;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\gfx;..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\components\libraries\mpu;..\..\..\..\..\..\components\libraries\mutex;..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\components\libraries\pwr_mgmt;..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\sdcard;..\..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\components\libraries\sortlist;..\..\..\..\..\..\components\libraries\spi_mngr;..\..\..\..\..\..\components\libraries\stack_guard;..\..\..\..\..\..\components\libraries\stack_info;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\svc;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\twi_mngr;..\..\..\..\..\..\components\libraries\twi_sensor;..\..\..\..\..\..\components\libraries\usbd;..\..\..\..\..\..\components\libraries\usbd\class\audio;..\..\..\..\..\..\components\libraries\usbd\class\cdc;..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\..\components\libraries\usbd\class\hid;..\..\..\..\..\..\components\libraries\usbd\class\hid\generic;..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd;..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse;..\..\..\..\..\..\components\libraries\usbd\class\msc;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser;..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ac_rec;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_oob_advdata;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_lib;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_msg;..\..\..\..\..\..\components\nfc\ndef\connection_handover\common;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ep_oob_rec;..\..\..\..\..\..\components\nfc\ndef\connection_handover\hs_rec;..\..\..\..\..\..\components\nfc\ndef\connection_handover\le_oob_rec;..\..\..\..\..\..\components\nfc\ndef\generic\message;..\..\..\..\..\..\components\nfc\ndef\generic\record;..\..\..\..\..\..\components\nfc\ndef\launchapp;..\..\..\..\..\..\components\nfc\ndef\parser\message;..\..\..\..\..\..\components\nfc\ndef\parser\record;..\..\..\..\..\..\components\nfc\ndef\text;..\..\..\..\..\..\components\nfc\ndef\uri;..\..\..\..\..\..\components\nfc\t2t_lib;..\..\..\..\..\..\components\nfc\t2t_lib\hal_t2t;..\..\..\..\..\..\components\nfc\t2t_parser;..\..\..\..\..\..\components\nfc\t4t_lib;..\..\..\..\..\..\components\nfc\t4t_lib\hal_t4t;..\..\..\..\..\..\components\nfc\t4t_parser\apdu;..\..\..\..\..\..\components\nfc\t4t_parser\cc_file;..\..\..\..\..\..\components\nfc\t4t_parser\hl_detection_procedure;..\..\..\..\..\..\components\nfc\t4t_parser\tlv;..\..\..\..\..\..\components\softdevice\common;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\external\mbedtls\include;..\..\..\..\..\..\external\micro-ecc\micro-ecc;..\..\..\..\..\..\external\nrf_cc310\include;..\..\..\..\..\..\external\nrf_oberon;..\..\..\..\..\..\external\nrf_oberon\include;..\..\..\..\..\..\external\nrf_tls\mbedtls\nrf_crypto\config;..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\external\utf_converter;..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\..\modules\nrfx\mdk;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x52000
  memory RVCT9: RAM 0x20002ba8 size 0xd458
  link misc: --diag_suppress 6330
  group Application
    ./: main.c slice_sm_button.c
    config/: sdk_config.h
  group Board Definition
    ../nRF5_SDK_15.2.0/components/boards/: boards.c
  group Board Support
    ../nRF5_SDK_15.2.0/components/libraries/bsp/: bsp.c bsp_btn_ble.c
  group UTF8/UTF16 converter
    ../nRF5_SDK_15.2.0/external/utf_converter/: utf.c
  group nRF_BLE
    ../nRF5_SDK_15.2.0/components/ble/peer_manager/: auth_status_tracker.c gatt_cache_manager.c gatts_cache_manager.c id_manager.c nrf_ble_lesc.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c peer_manager_handler.c pm_buffer.c security_dispatcher.c security_manager.c
    ../nRF5_SDK_15.2.0/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../nRF5_SDK_15.2.0/components/ble/ble_advertising/: ble_advertising.c
    ../nRF5_SDK_15.2.0/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../nRF5_SDK_15.2.0/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
    ../nRF5_SDK_15.2.0/components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
  group nRF_BLE_Services
    ../nRF5_SDK_15.2.0/components/ble/ble_services/ble_bas/: ble_bas.c
    ../nRF5_SDK_15.2.0/components/ble/ble_services/ble_dis/: ble_dis.c
    ./: ble_sensor.c
    ../nRF5_SDK_15.2.0/components/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_Crypto
    ../nRF5_SDK_15.2.0/components/libraries/crypto/: nrf_crypto_aead.c nrf_crypto_aes.c nrf_crypto_aes_shared.c nrf_crypto_ecc.c nrf_crypto_ecdh.c nrf_crypto_ecdsa.c nrf_crypto_eddsa.c nrf_crypto_error.c nrf_crypto_hash.c nrf_crypto_hkdf.c nrf_crypto_hmac.c nrf_crypto_init.c nrf_crypto_rng.c nrf_crypto_shared.c
  group nRF_Crypto backend Oberon
    ../nRF5_SDK_15.2.0/components/libraries/crypto/backend/oberon/: oberon_backend_chacha_poly_aead.c oberon_backend_ecc.c oberon_backend_ecdh.c oberon_backend_ecdsa.c oberon_backend_eddsa.c oberon_backend_hash.c oberon_backend_hmac.c
  group nRF_Crypto backend nRF HW
    ../nRF5_SDK_15.2.0/components/libraries/crypto/backend/nrf_hw/: nrf_hw_backend_init.c nrf_hw_backend_rng.c nrf_hw_backend_rng_mbedtls.c
  group nRF_Crypto backend uECC
    ../nRF5_SDK_15.2.0/components/libraries/crypto/backend/micro_ecc/: micro_ecc_backend_ecc.c micro_ecc_backend_ecdh.c micro_ecc_backend_ecdsa.c
  group nRF_Drivers
    ../nRF5_SDK_15.2.0/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_rng.c nrf_drv_uart.c nrf_drv_twi.c
    ../nRF5_SDK_15.2.0/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_power_clock.c nrfx_rng.c nrfx_uart.c nrfx_uarte.c nrfx_twi.c nrfx_twim.c nrfx_saadc.c
    ../nRF5_SDK_15.2.0/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../nRF5_SDK_15.2.0/components/libraries/button/: app_button.c
    ../nRF5_SDK_15.2.0/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../nRF5_SDK_15.2.0/components/libraries/scheduler/: app_scheduler.c
    ../nRF5_SDK_15.2.0/components/libraries/timer/: app_timer.c
    ../nRF5_SDK_15.2.0/components/libraries/crc16/: crc16.c
    ../nRF5_SDK_15.2.0/components/libraries/fds/: fds.c
    ../nRF5_SDK_15.2.0/components/libraries/hardfault/: hardfault_implementation.c
    ../nRF5_SDK_15.2.0/components/libraries/mem_manager/: mem_manager.c
    ../nRF5_SDK_15.2.0/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../nRF5_SDK_15.2.0/components/libraries/atomic_flags/: nrf_atflags.c
    ../nRF5_SDK_15.2.0/components/libraries/atomic/: nrf_atomic.c
    ../nRF5_SDK_15.2.0/components/libraries/balloc/: nrf_balloc.c
    ../nRF5_SDK_15.2.0/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../nRF5_SDK_15.2.0/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../nRF5_SDK_15.2.0/components/libraries/memobj/: nrf_memobj.c
    ../nRF5_SDK_15.2.0/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../nRF5_SDK_15.2.0/components/libraries/queue/: nrf_queue.c
    ../nRF5_SDK_15.2.0/components/libraries/ringbuf/: nrf_ringbuf.c
    ../nRF5_SDK_15.2.0/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../nRF5_SDK_15.2.0/components/libraries/strerror/: nrf_strerror.c
    ../nRF5_SDK_15.2.0/components/libraries/sensorsim/: sensorsim.c
    ./twi/: app_twi.c
    ../nRF5_SDK_15.2.0/components/libraries/uart/: app_uart_fifo.c
    ../nRF5_SDK_15.2.0/components/libraries/fifo/: app_fifo.c
  group nRF_Log
    ../nRF5_SDK_15.2.0/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Oberon_Crypto
    ../nRF5_SDK_15.2.0/external/nrf_oberon/lib/nrf52/: oberon_short_wchar_2.0.5.lib
  group nRF_Segger_RTT
    ../nRF5_SDK_15.2.0/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../nRF5_SDK_15.2.0/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group nRF_TLS
    ../nRF5_SDK_15.2.0/external/mbedtls/library/: aes.c ctr_drbg.c
  group nrf_cc310
    ../nRF5_SDK_15.2.0/external/nrf_cc310/lib/: nrf_cc310_keil_0.9.10.lib
  group afe4409
    ./afe4409/: afe4409.c mma8451.c
  group TWI
    ./twi/: twi.c
  group nRF_DFU
    ../nRF5_SDK_15.2.0/components/ble/ble_services/ble_dfu/: ble_dfu.c ble_dfu_bonded.c ble_dfu_unbonded.c
    ../nRF5_SDK_15.2.0/components/libraries/bootloader/dfu/: nrf_dfu_svci.c
target flash_s132_nrf52_6.1.0_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.42.0
  cpu: as above
  output: s132_nrf52_6.1.0_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\..\config;..\config
  asm define: __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5a000
  memory RVCT9: RAM 0x20002b90 size 0xd470
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 4.3.0, Device:Startup 8.17.0
